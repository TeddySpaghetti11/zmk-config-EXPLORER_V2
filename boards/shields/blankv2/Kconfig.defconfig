## boards/shields/blankv2/Kconfig.defconfig
```kconfig
if SHIELD_BLANKV2

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "blankv2"

endif
```
